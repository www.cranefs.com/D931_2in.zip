# Autodesk Inventor part: D931_2inA
## iProperties
Created: 2011-03
Part Number: D931_2inA
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
